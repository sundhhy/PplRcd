# Keil uVision project PplRcd.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PplRcd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,HSE_VALUE=8000000
  c misc: --diag_suppress=1295;--diag_suppress=1;--diag_suppress=177-D
  c include: .\configs;.\BSP;E:\mylib\sdhLib\inc;.\device\dev_LCD\nokia_5110;..\PplRcd;.\drive;.\device;.\Glyph;.\Expression;.\Views;.\REEC;.\MVC;.\Views;..\PplRcd;.\model;.\sheet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./: main.c Semaphore.c TDD.h sdhlibConf.h
  group config
    ./configs/: hardwareConfig.c hardwareConfig.h
  group BSP
    ./BSP/: pinmux.h pinmux.c mySystemClock.c mySystemClock.h intrInit.c intrInit.h
  group myLib
    E:/mylib/sdhLib/inc/basis/: sdhDebug.h sdhError.h assert.h
    E:/mylib/sdhLib/src/basis/: marco.c except.c assert.c
    E:/mylib/sdhLib/src/mem/: Ping_PongBuf.c mem.c
    E:/mylib/sdhLib/inc/mem/: Ping_PongBuf.h
    E:/mylib/sdhLib/inc/: sdhDef.h lw_oopc.h
    E:/mylib/sdhLib/src/arithmetic/: list.c cycQueue.c
    E:/mylib/sdhLib/inc/arithmetic/: cycQueue.h list.h
    ./: sdhlibConf.h
    E:/mylib/sdhLib/inc/os/: os_depend.h
    E:/mylib/sdhLib/inc/os/rtx/: rtx_depend.h
    E:/mylib/sdhLib/src/os/RTX/: rtx_depend.c
  group dev_LCD
    ./device/dev_LCD/nokia_5110/: nokia_5110.c
    ./device/dev_LCD/UsartGpu/: dev_LcdUsartGpu.c dev_LcdUsartGpu.h
  group drive
    ./drive/uart/: drive_uart.c drive_uart.h
    ./drive/GPIO/: drive_gpio.c drive_gpio.h
  group device
    ./device/: device.h device.c deviceId.h dev_cmd.h dev_lcd.c dev_lcd.h
  group dev_char
    ./device/: dev_char.h dev_char.c
    ./device/dev_uart/: dev_uart.h dev_uart.c
    ./device/dev_gpio/: device_gpio.h device_gpio.c
  group Glyph
    ./Glyph/: glyph.c testGlyph.c glyph.h testGlyph.h Gh_txt.c Gh_txt.h Gh_Rectangle.h Gh_Rectangle.c Gh_None.h Gh_None.c Gh_Pic.c Gh_Pic.h
  group expression
    ./Expression/: expression.c expression.h TxtExpr.h TxtExpr.c Reader.c ExpFactory.c ExpFactory.h NtButton.c NtButton.h Reader.h BrExpr.c BrExpr.h NtInput.c NtInput.h GeometricsExpr.h GeometricsExpr.c NtGrid.c NtGrid.h PicExpr.c PicExpr.h
  group utils
    ./utils/: rtc.c rtc.h time.h rtc_pcf8563.h rtc_pcf8563.c keyboard.c keyboard.h times.c
  group sheet
    ./sheet/: sheet.c sheetMemento.c sheet.h sheetMemento.h
  group HMI
    ./HMI/: commHMI.c commHMI.h HMIFactory.c HMIFactory.h HMI.c HMI.h mainHMI.c mainHMI.h format.c format.h keyboardHMI.c keyboardHMI.h chnInfoPic.c chnInfoPic.h menuHMI.c menuHMI.h barGraphHmi.c barGraphHmi.h dataHmi.c dataHmi.h real_time_trendHmi.c real_time_trendHmi.h curve.c curve.h focus.c focus.h news_select_HMI.c news_select_HMI.h News_Alarm_HMI.h News_Alarm_HMI.c News_Power_down_HMI.h News_Power_down_HMI.c Accumulate_HMI .c Accumulate_HMI.h Setup_HMI.c Setup_HMI.h Setting_HMI.c Setting_HMI.h Set_system_strategy.c Set_system_strategy.h Set_channel_strategy.c Set_alarm_strategy.c Set_arithmetic_strategy.c Set_view_strategy.c Set_dataBackUp_strategy.c Set_dataPrint_strategy.c Acc_day.c Acc_month.c windownsHMI.c windowsHMI.h
  group model
    ./model/: Model.c ModelFactory.c ModelTime.c Model.h ModelFactory.h ModelTime.h ModelTest.h ModelTest.c
  group control
    ./Control/: Controller.c Controller.h CtlKey.c CtlKey.h CtlTimer.c CtlTimer.h
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
